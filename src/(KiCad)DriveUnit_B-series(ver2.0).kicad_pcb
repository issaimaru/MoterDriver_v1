# Repository issaimaru/MoterDriver_v1

File README.md:

# DriveUnit Bseries
**[自作電源基板](https://github.com/Issaimaru/PowerSupply_v1)に刺して使う80A級モータードライバ**<br>
**[DUB with 遠野](https://github.com/Issaimaru/DUB_with_Tono)を使って遠野に刺すこともできます**<br>
**動作電圧 8[V]~30[V]**<br>
**PWM周波数 ~250kHz**<br>
**duty比 100%対応**<br>
**電圧監視機能搭載**<br>
**LAP/SM方式での駆動が可能**<br>
**制作期間:2022/01/18頃～**<br>
**名前:DriveUnit Bseries**<br>

## バージョンに対応するドキュメント
- ver1.0-->[README_v1.md](https://github.com/Issaimaru/MoterDriver_v1/blob/master/README_v1.md)
- ver2.0-->[README_v2.md](https://github.com/Issaimaru/MoterDriver_v1/blob/master/README_v2.md)

## 前モータードライバ(野獣)との違い
野獣がノートパソコンで，DUBがゲーミングパソコンと例えるとわかりやすいと思います．(やや過言かもしれないです...)<br>
野獣ができることは基本的にDUBでもできますし，野獣でできないような機能もDUBにはありますが，値段とサイズ的にはDUBが劣ります．<br>
- **PWM比1.0での動作が可能**<br>
このモータードライバで使用しているA3921というゲートドライバは，ハイサイドにチャージポンプを内蔵しています．そのため，PWM比が1.0の近くであっても正常に動作することができます．<br>

- **動作周波数帯域が増えた**<br>
    > 100Hz以上10000Hz未満なら一応動く。一番特性がいいのは2kHz。<br>
 
  富山本郷メカテック部wikiの野獣の説明にはこのように書いてありますが，20kHzまでは人間の可聴域なので20kHz以下でモータを駆動させると大きな音がモータから発せられてしまいます．      <br>DriveUnit Bseries(以下，DUBといいます．)は ~~**計算上では**100kHzでも動作します．これは実験で確かめます．~~　<br>
  実験したところ，mbedではPWM周波数に比例してPWM分解能が小さくなるため，20kHzを超えると明らかにモーターの動作が不安定になります．
  <br>STM32CubeIDEからHALドライバーを使用し，タイマーの設定を変更することでこの問題を解消することができますが([ここ](https://qiita.com/ShunHattori/items/68f099f1d77702d2535d)を参照)，普通はオンラインコンパイラから制御しますよね...(実際にHALドライバーを使用してやってみましたが色々めんどくさいです)<br>
  上記の問題から，HALドライバーを使用せずにこのモータードライバを使用する場合は10kHz~20kHzで使用することを推奨します．(可聴域内ですが，音は聞こえないです．)<br>
  また，HALドライバーを使用する場合は250kHz以下の周波数で使用するようにしてください．
  
- **LAP/SM方式の切り替えが可能**<br>
このモータードライバで使用しているA3921というゲートドライバの配線をうまくしてやると，PWM方式(LAP/SM)をスイッチ一つで切り替えることが実現できます．SM方式はPWM比がそのまま回転数と比例し，効率がよく，低周波でも線形性が比較的保たれるのに対して，LAP方式は正転と逆転の比率を調整してモータの回転方向と回転速度を変化させる方式であり，Duty比50%でモーターが停止するという違いがあります．

- **定格電圧が大きくなった**<br>
モータードライバでは逆起電力が生じるため加える電圧の2倍程度のマージンを取る必要がある(と他高専のOBの方からアドバイスを頂きました．)<br>そのため， $V_{DS}$ が30 $V$ のFETを使用し，コンデンサやゲートドライバの耐圧も30 $V$ 以上になるように選定しました．<br>また，パスコンには(これも他高専のOBの方のアドバイスで)高分子コンデンサを使用しました．<br>そのため，野獣よりも逆起電力に強くなりましたが，6セルのリポバッテリー等を使って急減速をすると逆起電力で普通に30 $V$ を超えます(上の「特性」を参照)．そのため，6セルのリポバッテリー等を使用する場合は電源ラインをオシロスコープで確認して，逆起電力で30 $V$ を超えないか確認することを推奨します．

- **ボタンでモータを制御できるようになった**<br>
MD10Cのように，ボタンでモータの正転，逆転を制御できるようにしました．

- **定格電流が大きくなった**<br>
DUBでは(これも実験で確かめますが)最大で連続80 $A$ の電流を流すことができます．しかし，ハピロボ以降のロボコンは30 $A$ 以下という電流制限があるため，電源基板側にリセッタブルヒューズがついています．そのためあまり意味はありません．<br>

- **電圧監視機能が付いた**<br>
これもA3921の機能ですが，ハイサイドのFETの $V_{DS}$ 間の電圧を監視することによって万が一短絡した場合でもすぐに動作を止めてくれるほか，オーバーヒートしてるような状態なども検知してFFXのLEDを光らせることで警告してくれます．<br>
A3921のデータシートから取ってきたものですが，各FFピンの出力に対する説明は以下の表の通りとなっています．<br>

- **逆接しにくくなった**<br>
エッジコネクタは物理的に逆接が不可能な状態になっていませんが，野獣は勿論のことこのモータードライバも逆接すると燃えます．<br>
そのため，このモータードライバと電源基板では三角の印をつけることで接続する向きが把握しやすいようにしました．<br>

## はんだ付けの仕方
長くなるのでたたみます．
<details><summary>はんだ付けの仕方</summary>
まず初めに，このモータードライバのはんだ付けはとてもめんどくさいです．<br>
なぜなら，はんだごてではんだ付けするにはあまりにも小さすぎる部品を使っているため，リフローをする必要があるからです(恐らく部内でリフローする基板はこれが初めて)．<br>
といっても，部内にはリフローオーブンなんてないので....<br>

<br>
ホットプレートを使用したホットプレートリフローではんだ付けしています．<br>
ていっても，基板は両面ありますが片面をホットプレートリフローしてもう片面も同じようにやろうとすると，はんだ付け済みの面が先に温まってしまうので両面をこの方法ですることはできません．そこでもう片面は.......<br>

ヒートガンを使用したヒートガンリフローではんだ付けしています．<br>
そのため，~~本当にめんどくさい~~ですが一気にはんだ付けできるため手はんだとどっちがめんどくさいかと聞かれるとどっちもどっちかなと思います．<br>
とりあえず，はんだづけの仕方を書いておかないと正直量産は自分以外に難しくなってしまうのでここに書いておきます．<br>

まず，ホットプレートリフローをする面は裏面(下の画像で示している面)です．<br>
<br>

理由は，この基板ではんだ付けが一番難しい部品がこの面のICで，こっちの面をヒートガンでリフローするとリフローの風ではんだが飛んで隣同士がくっついてしまう可能性があるからです．<br>
ホットプレートリフローについては[ここ](https://qiita.com/azusa9/items/a2fc4f26799de5588c58)を見ればやり方は完全理解することができると思いますが，一応自分流のやり方を書いておきます．<br>

1. いらない基板を3つ用意してDUBを囲うように配置する．
    <br>
    画像のように，DUBより大きめの基板をDUBの周りに配置します．<br>

1. テープ(できれば養生)で固定する．
    <br>
    こんな感じでDUBが動かないように固定してください．あとから剥がすので養生の方がいいです．自分は家に養生テープがなかったのでセロハンテープでやってます．

1. ステンシル(メタルマスク)をパッドに合わせて上だけテープで固定する
    <br>
    ステンシルの穴がパッドにしっかりと合うようにして，上だけをテープで固定します．<br>
    上だけを固定する理由は後で説明します．

1. クリーム半田をいらないカード等で伸ばしながら塗る<br>
    
    <br>
    部室に画像のようなクリームはんだがあると思います．(なければ買ってください．自分は[ここ](https://www.amazon.co.jp/gp/product/B09QCQ12RV/ref=ppx_yo_dt_b_asin_title_o00_s00?ie=UTF8&psc=1)で買いました．)<br>
    これをまずはステンシルに落として，いらないカードなどで伸ばして基板のパッド全てに塗られるようにしてください．<br>
    自分は部室にこれを忘れてきたので塗りませんが，こんな感じです([超簡単、ホットプレートでリフロー（はんだ付け）！](https://qiita.com/azusa9/items/a2fc4f26799de5588c58#%E3%81%84%E3%81%96%E3%82%AF%E3%83%AA%E3%83%BC%E3%83%A0%E5%8D%8A%E7%94%B0%E5%A1%97%E3%82%8A)より引用)．<br>

    <br>

1. ステンシルの上に貼ったテープを支点にステンシルを持ち上げ，部品を乗せる．<br>
    ステンシルの固定の際に上だけをテープで固定した理由はこれを支点にステンシルを持ち上げるからです．<br>
    塗ったクリームはんだを壊さないようにゆっくりと持ち上げたら，いよいよ部品をピンセットで載せていきます．<br>
    ここで注意点をまとめておきます．<br>
    
    - 部品を乗せる際，きっちり押さえつける必要はない．
    - リフローの際に自然にパターンの位置に部品が動くため，多少部品がずれていても修正しない．
    - 特にIC部ははんだが隣同士でくっつくが，修正せずにICを載せる．
    
    以上の注意点を頭に入れながら，部品を載せていきます．<br>
    ちなみに載せるのは表面実装部品のみで，スルーホール部品はまだはんだ付けしません．<br>
    いちいち回路図を参照しながら部品を載せるのはめんどくさいと思うのでここに載せる部品をまとめておきます．(これはver1.0の部品配置です．ver1.0以降のバージョンの部品配置は各ドキュメントに示しておきます．)<br>
    <br>
    この画像の通りに部品を配置したら，いよいよホットプレートリフローに入ります．<br>

1. ホットプレートリフロー!<br>
    ホットプレートの中心に部品を載せた基板を置き，ホットプレートを加熱していきましょう．部室にあるホットプレートなら中~強の間に合わせればいいと思います．<br>
    そのまま待っていると，煙がでてきてクリームはんだが溶け，金属光沢が現れると思います．全体的にクリームはんだがこの状態になったらホットプレートの加熱をやめ，動かさずに冷えるまで待ってください．<br>
    冷えてはんだが固まったら裏面については終わりです．お疲れ様でした．最後に導通試験をしてください(特にIC)．<br>
    <br>
    **ICの隣同士がくっついていた場合**<br>
    これはよくあります．こうなった場合は，ハンダ吸い取り線で吸い取ってやるとうまく離れると思います．試してみてください．

1. 表面もはんだペーストを塗って部品を配置する<br>
    手順1~5と同様にして表面についてもはんだペーストを塗って，部品を載せます．<br>
    載せる部品をここにまとめておきます．<br>
    ここで，タクトスイッチの裏に丸い突起があるためそのまま置くとパッド面と密着しないと思います．<br>
    そのため突起をニッパー等で取ってから置くようにしてください．<br>

1. ヒートガンリフロー!<br>
    ヒートガンの風を直にあてて基板を加熱していきます．<br>
    設定は弱風にして，チップLEDの真上にヒートガンがあるようにしてください(チップLEDがヒートガンの風で吹き飛ばされる可能性があるため)．<br>
    このとき，机がヒートガンの熱で壊れる可能性があるので，可能であれば作業マットの上に基板をおいて作業をしましょう．<br>
    この状態でしばらくすると，チップLEDの周りの部品だけはんだが溶けてくると思います．<br>
    はんだが完全に溶けたら，ヒートガンを下にもっていって，タクトスイッチ等についても同様にリフローを行ってください．<br>
    全てのはんだペーストが溶けたら加熱をやめ，動かさずに冷えるまで待ってください．<br>
    冷えてはんだが固まったら表面実装部品のはんだ付けは終わりです．お疲れ様でした．<br>
    <br>
    **タクトスイッチがパッド面と密着せず，リフローに失敗した場合**<br>
    この場合は手はんだではんだ付けしてください．<br>

1. スルーホール部品を手はんだではんだ付けする<br>
    ここまで来たら楽です．あとはいつも通りスルーホール部品をはんだ付けしてください．<br>
    注意点をまとめておきます．<br>
    
    - FETのドレインのピン(3ピンあるうちの真ん中のピン)はニッパーで切る
    - 電解コンデンサは，基板が白で塗りつぶされている方がマイナス(紫色の印がある方)になるように付ける

1. 完成!<br>
    お疲れ様でした．最後に動作試験をしてみてちゃんと動いたらはんだ付けが正しくできています．    

</details>

## 回路図のダウンロード(クローン)方法
1. Gitをインストールします．<br>Gitのインストール方法は[ここ](https://www.sejuku.net/blog/73444)を参照してください．
1. コマンドプロンプトを立ち上げます．
1. `cd ”ダウンロード先フォルダの絶対パス” `<br>
1. `git clone https://github.com/Issaimaru/MoterDriver_v1.git`<br>

## KiCad design src/(KiCad)DriveUnit_B-series(ver2.0).kicad_pcb

Board: 2 copper layers, 65.7 x 51.0 mm, 65 parts (0 on the bottom side), 43 nets.

Parts:
A3921: A3921
C1, C2, C3, C4, C5, C7, C8: GCM188L81H104KA57
C6: GCM21BR71H474KA55
C9: GRT31CC81H225KE01L
C10, C11: 35PZJ330M10X9
C12: GRM32ER7YA106KA12
C13: GRM21BC72A105KE01
D1, D2, D3, D4, D5: GS1010FL
EDGE1: 10046971-019LF
HA: IRLB3813NOHOLE; TO-220AB-NOHOLE
HB: IRLB3813NOHOLE; TO-220AB-NOHOLE
LA: IRLB3813NOHOLE; TO-220AB-NOHOLE
LB: IRLB3813NOHOLE; TO-220AB-NOHOLE
LED1, LED2, LED3, LED4, LED5: SML-E12V8WT86
R1, R4, R5, R6, R9, R11, R15, R16, R17, R18, R19, R24, R25: RG2012
R2: RG2012N-332-W-T1; RG2012
R3, R22: RG2012P-681-B-T5; RG2012
R7, R8, R26, R27: RG2012N-201-W-T1; RG2012
R10, R12, R20, R21: RG2012Q-100-D-T5; RG2012
R13: RG2012P-302-B-T5; RG2012
R14: RG2012N-222-W-T1; RG2012
RESET: THAF01-NC-R
SA: TVAF06-A020B-R
SB: TVAF06-A020B-R
SW4: SS-12D00G3
TLP1, TLP2: TLP2366
TR1, TR2, TR3, TR4: 2SC3325

Connections:
/DIR: A3921.19, D3.A, R17.RIGHT, TR4.C
/DIR_IN: EDGE1.P$26, R26.RIGHT
/FF1: A3921.25, R4.LEFT, TR1.B
/FF2: A3921.26, R5.LEFT, TR2.B
/GHA: A3921.10, R21.RIGHT
/GHB: A3921.5, R12.LEFT
/GLA: A3921.12, R20.RIGHT
/GLB: A3921.3, R10.LEFT
/GND_IN: EDGE1.P$24, TLP1.3, TLP2.3
/LAP: D4.A, D5.A, R9.LEFT, R25.LEFT, SW4.C, TR3.B
/PWM: A3921.23, R6.RIGHT, TR3.C
/PWM_IN: EDGE1.P$25, R27.RIGHT
/RESET: A3921.24, R11.LEFT, RESET.3
/SA: A3921.11, C8.P$2, EDGE1.P$1, EDGE1.P$2, EDGE1.P$3, EDGE1.P$4, EDGE1.P$5, EDGE1.P$45, EDGE1.P$46, EDGE1.P$47, EDGE1.P$48, EDGE1.P$49, EDGE1.P$50, HA.SOURCE, LA.DRAIN, R3.LEFT, R16.LEFT
/SB: A3921.4, C7.P$2, EDGE1.P$6, EDGE1.P$7, EDGE1.P$8, EDGE1.P$9, EDGE1.P$10, EDGE1.P$11, EDGE1.P$40, EDGE1.P$41, EDGE1.P$42, EDGE1.P$43, EDGE1.P$44, HB.SOURCE, LB.DRAIN, LED1.K, LED2.A, R19.LEFT
/V5: A3921.20, A3921.21, A3921.22, C1.P$2, C2.P$2, C3.P$2, R4.RIGHT, R5.RIGHT, R6.LEFT, R7.LEFT, R8.LEFT, R14.LEFT, R17.LEFT, TLP1.6, TLP2.6
GND: A3921.2, A3921.17, A3921.PAD, C1.P$1, C2.P$1, C3.P$1, C4.P$1, C5.P$1, C9.P$2, C10.C, C11.C, C12.P$2, C13.P$2, EDGE1.P$28, EDGE1.P$29, EDGE1.P$30, EDGE1.P$31, EDGE1.P$32, EDGE1.P$33, EDGE1.P$34, EDGE1.P$35, EDGE1.P$36, EDGE1.P$37, EDGE1.P$38, EDGE1.P$39, LA.SOURCE, LB.SOURCE, LED3.K, R2.RIGHT, R13.RIGHT, R15.LEFT, R18.LEFT, R24.RIGHT, R25.RIGHT, RESET.1, SA.LEFT, SB.RIGHT, SW4.R, TLP1.4, TLP2.4, TR1.E, TR2.E, TR3.E, TR4.E
unnamed: A3921.8, C4.P$2, C9.P$1
unnamed: A3921.13, C5.P$2, D1.C
unnamed: A3921.15, C6.P$1
unnamed: A3921.16, C6.P$2
unnamed: A3921.6, C7.P$1
unnamed: A3921.9, C8.P$1
unnamed: D2.A, R1.LEFT, R24.LEFT, TR4.B
unnamed: D2.C, D4.C, SA.RIGHT
unnamed: D3.C, D5.C, SB.LEFT
unnamed: HA.GATE, R16.RIGHT, R21.LEFT
unnamed: HB.GATE, R12.RIGHT, R19.RIGHT
unnamed: A3921.27, R13.LEFT
unnamed: A3921.28, R2.LEFT, R14.RIGHT
unnamed: LA.GATE, R15.RIGHT, R20.LEFT
unnamed: LB.GATE, R10.RIGHT, R18.RIGHT
unnamed: LED1.A, LED2.K, R3.RIGHT
unnamed: LED3.A, R22.RIGHT
unnamed: LED4.A, R7.RIGHT
unnamed: LED4.K, TR1.C
unnamed: LED5.A, R8.RIGHT
unnamed: LED5.K, TR2.C
unnamed: R1.RIGHT, TLP1.5
unnamed: R9.RIGHT, TLP2.5
unnamed: R26.LEFT, TLP1.1
unnamed: R27.LEFT, TLP2.1
VCC: A3921.1, C10.A, C11.A, C12.P$1, C13.P$1, D1.A, EDGE1.P$12, EDGE1.P$13, EDGE1.P$14, EDGE1.P$15, EDGE1.P$16, EDGE1.P$17, EDGE1.P$18, EDGE1.P$19, EDGE1.P$20, EDGE1.P$21, EDGE1.P$22, EDGE1.P$23, HA.DRAIN, HB.DRAIN, R11.RIGHT, R22.LEFT

## KiCad design src/DriveUnit_B-series(ver1.0).kicad_pcb

Parts:
3813-HA1, 3813-HB1, 3813-LA1, 3813-LB1: IRLB3813NOHOLE; TO-220AB-NOHOLE
C1, C2, C3, C4, C5, C7, C8: GCM188L81H104KA57
C6: GCM21BR71H474KA55
C9: GRT31CC81H225KE01L
C10, C11: 35PZJ330M10X9
C12: GRM32ER7YA106KA12
C13: GRM21BC72A105KE01
D1, D8, D9: GS1010FL
EDGE1: 10046971-019LF
IC1: A3921
LED1, LED2, LED3, LED4, LED5: SML-E12V8WT86
R1, R9, R11, R15, R16, R18, R19: RG2012
R2: RG2012N-332-W-T1; RG2012
R3, R22: RG2012P-681-B-T5; RG2012
R5, R6: RG2012-N-102-B-T5; RG2012
R7, R8: RG2012N-201-W-T1; RG2012
R10, R12, R20, R21: RG2012Q-100-D-T5; RG2012
R13: RG2012P-302-B-T5; RG2012
R14: RG2012N-222-W-T1; RG2012
SW1, SW2: TVAF06-A020B-R
SW3: THAF01-NC-R
SW4: SS-12D00G3
TLP1, TLP2: TLP2366
TR1, TR2: 2SC3325

Connections:
/DIR: D8.C, IC1.19 (PHASE), R1.LEFT
/DIR_IN: EDGE1.P$26 (P26); also elsewhere on the board
/FF1: IC1.25 (FF1), R5.RIGHT, TR1.B
/FF2: IC1.26 (FF2), R6.RIGHT, TR2.B
/GHA: IC1.10 (GHA), R21.RIGHT
/GHB: IC1.5 (GHB), R12.LEFT
/GLA: IC1.12 (GLA), R20.RIGHT
/GLB: IC1.3 (GLB), R10.LEFT
/GND_IN: EDGE1.P$24 (P24), TLP1.3 (CATHODE)
/PWM: D9.C, IC1.23 (PWMH), R9.LEFT, SW2.LEFT, SW4.R
/PWM_IN: EDGE1.P$25 (P25), TLP2.3 (CATHODE)
/RESET: IC1.24 (RESET), R11.LEFT, SW3.3
/SA: 3813-HA1.SOURCE (S), 3813-LA1.DRAIN (D), C8.P$2, EDGE1.P$1 (P1), EDGE1.P$2 (P2), EDGE1.P$3 (P3), EDGE1.P$4 (P4), EDGE1.P$5 (P5), EDGE1.P$45 (P45), EDGE1.P$46 (P46), EDGE1.P$47 (P47), EDGE1.P$48 (P48), EDGE1.P$49 (P49), EDGE1.P$50 (P50), IC1.11 (SA), R3.LEFT, R16.LEFT
/SB: 3813-HB1.SOURCE (S), 3813-LB1.DRAIN (D), C7.P$2, EDGE1.P$6 (P6), EDGE1.P$7 (P7), EDGE1.P$8 (P8), EDGE1.P$9 (P9), EDGE1.P$10 (P10), EDGE1.P$11 (P11), EDGE1.P$40 (P40), EDGE1.P$41 (P41), EDGE1.P$42 (P42), EDGE1.P$43 (P43), EDGE1.P$44 (P44), IC1.4 (SB), LED1.K (C), LED2.A, R19.LEFT
/V5: C1.P$2, C2.P$2, C3.P$2, IC1.20 (V5), IC1.21 (SR), IC1.22 (PWML), R5.LEFT, R6.LEFT, R7.LEFT, R8.LEFT, R14.LEFT, SW1.LEFT, SW2.RIGHT (S), SW4.C, TLP1.6 (VCC), TLP2.6 (VCC)
/VCC_IN: EDGE1.P$27 (P27); also elsewhere on the board
GND: 3813-LA1.SOURCE (S), 3813-LB1.SOURCE (S), C1.P$1, C2.P$1, C3.P$1, C4.P$1, C5.P$1, C9.P$2, C10.C (CATHODE), C11.C (CATHODE), C12.P$2, C13.P$2, EDGE1.P$28 (P28), EDGE1.P$29 (P29), EDGE1.P$30 (P30), EDGE1.P$31 (P31), EDGE1.P$32 (P32), EDGE1.P$33 (P33), EDGE1.P$34 (P34), EDGE1.P$35 (P35), EDGE1.P$36 (P36), EDGE1.P$37 (P37), EDGE1.P$38 (P38), EDGE1.P$39 (P39), IC1.2 (LSS), IC1.17 (GND), LED3.K (C), R2.RIGHT, R13.RIGHT, R15.LEFT, R18.LEFT, SW3.1, TLP1.4 (GND), TLP2.4 (GND), TR1.E, TR2.E
unnamed: 3813-HA1.GATE (G), R16.RIGHT, R21.LEFT
unnamed: 3813-HB1.GATE (G), R12.RIGHT, R19.RIGHT
unnamed: 3813-LA1.GATE (G), R15.RIGHT, R20.LEFT
unnamed: 3813-LB1.GATE (G), R10.RIGHT, R18.RIGHT
unnamed: C4.P$2, C9.P$1, IC1.8 (VREG)
unnamed: C5.P$2, D1.C, IC1.13 (VBB)
unnamed: C6.P$1, IC1.15 (CP2)
unnamed: C6.P$2, IC1.16 (CP1)
unnamed: C7.P$1, IC1.6 (CB)
unnamed: C8.P$1, IC1.9 (CA)
unnamed: D8.A, D9.A, SW1.RIGHT (S)
unnamed: IC1.27 (RDEAD), R13.LEFT
unnamed: IC1.28 (VDSTH), R2.LEFT, R14.RIGHT
unnamed: LED1.A, LED2.K (C), R3.RIGHT
unnamed: LED3.A, R22.RIGHT
unnamed: LED4.A, R7.RIGHT
unnamed: LED4.K (C), TR1.C
unnamed: LED5.A, R8.RIGHT
unnamed: LED5.K (C), TR2.C
unnamed: R1.RIGHT, TLP1.5 (VOUT)
unnamed 40: TLP1.1 (ANODE); also elsewhere on the board
unnamed: R9.RIGHT, TLP2.5 (VOUT)
unnamed 42: TLP2.1 (ANODE); also elsewhere on the board
VCC: 3813-HA1.DRAIN (D), 3813-HB1.DRAIN (D), C10.A (ANODE), C11.A (ANODE), C12.P$1, C13.P$1, D1.A, EDGE1.P$12 (P12), EDGE1.P$13 (P13), EDGE1.P$14 (P14), EDGE1.P$15 (P15), EDGE1.P$16 (P16), EDGE1.P$17 (P17), EDGE1.P$18 (P18), EDGE1.P$19 (P19), EDGE1.P$20 (P20), EDGE1.P$21 (P21), EDGE1.P$22 (P22), EDGE1.P$23 (P23), IC1.1 (VDRAIN), R11.RIGHT, R22.LEFT

Notes on the sheet:
2020年度回路班
PWM
DIR
今の設計ではDIR=1の時正転,DIR=0の時逆転であり、野獣と逆になっている NOT回路をつければ解決可能だが部品点数が多くなり費用が高くなる
パスコン、昇圧用コンデンサ、抵抗等は今は仮決め(適当なスルーホール部品)(後で消すのを忘れない)
RESET
GLB
GHB
GHA
GLA
FF2
FF1
ローサイドFETのソース→GND 従ってLSS-GND →と思ったがノイズを産む可能性があるためできる だけソースと繋げる
作業する前にここにきてステータスをオンに変えるんだ~~~(やることも書いてあります) https://docs.google.com/spreadsheets/d/1alXVjfJdgJkTSt8yICWPKED-AMP4SQioRdKHuPwMju4/edit#gid=0
逆電圧防止
ブートストラップ→一般式912/13.75[nF] 0.066[uF]近くにする→0.1[uF]に訂正
パスコンくん
プルアップ抵抗(RESETをGNDに接続するとRESET)
”オープンドレイン”
参考(にしないほうがいいかもしれない)記事:https://qiita.com/TakenMaker/items/3c1aff6e6718ecfb7793
button1
button2
この抵抗つけないと多分だめ
リセットボタン
短絡させるとLAP方式になるよ！！
充電時間 MD動作中→0.46[us] 訂正後 0.6[us] 電源投入時→9.1[us] 訂正後 12[us]
Qg=45.6[nC](Vgs=12[V])[有効数字考慮46]
0.180[us]
別に適当でよさそう
800[kΩ]<=R
プルダウン抵抗の値は適当
V5の最大駆動電流28[mA]を超えないようにする
←LEDが壊れないくらいの抵抗値→
+put
-put
H-bridge
LED
Battery
Edge connector
A3921

Notices in the files:
src/(KiCad)DriveUnit_B-series(ver2.0).kicad_pcb:
Copyright © 2022 Issaimaru All Rights Reserved.
